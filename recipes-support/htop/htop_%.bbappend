FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

CFLAGS .= "-static"
